# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c include: ..\User\System;..\User\Hardware\LED;..\User\Hardware\TIMER;..\User\Hardware\PWM;..\User\Hardware\PWD;..\User\Hardware\I2C;..\User\Calculate;..\User\Hardware\GPIO
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group SYSTEM
    ../User/System/: sys_config.c delay.c
  group USER
    ../User/: main.c
  group HARDWARE
    ../User/Hardware/PWM/: pwm.c
    ../User/Hardware/PWD/: pwd.c
    ../User/Hardware/I2C/: iic.c sensors.c
    ../User/Hardware/GPIO/: GPIO.c
  group LIB
    ../Library/: STM32F10xR.LIB
  group CALCULATE
    ../User/Calculate/: kalmanfilter.c PID.c
